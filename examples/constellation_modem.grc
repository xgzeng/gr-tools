options:
  parameters:
    generate_options: qt_gui
    id: constellation_modem
    output_language: python
  states: {}

blocks:
- name: constellation
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.02'
    stop: '1'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: ber_sink_0
  id: ber_sink
  parameters: {}
  states: {}
- name: ber_source_0
  id: ber_source
  parameters: {}
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_constellation_demodulator_0
  id: digital_constellation_demodulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: '0.35'
    log: 'False'
    samples_per_symbol: '2'
    verbose: 'False'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: constellation
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    name: '"With Noise"'
    size: '1024'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [ber_source_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', digital_constellation_demodulator_0, '0']
- [blocks_add_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_1, '0']
- [blocks_pack_k_bits_bb_0, '0', ber_sink_0, '0']
- [blocks_throttle_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_demodulator_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_add_xx_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_pack_k_bits_bb_0, '0']

metadata:
  file_format: 1

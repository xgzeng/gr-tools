options:
  parameters:
    author: zengxg
    generate_options: qt_gui
    id: symbol_error_rate
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: symbol_error_rate_sink_0
  id: symbol_error_rate_sink
  parameters: {}
  states: {}
- name: symbol_error_rate_source_0
  id: symbol_error_rate_source
  parameters: {}
  states: {}

connections:
- [symbol_error_rate_source_0, '0', symbol_error_rate_sink_0, '0']

metadata:
  file_format: 1

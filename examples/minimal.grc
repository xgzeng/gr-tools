options:
  parameters:
    generate_options: qt_gui
    id: minimal
    output_language: python
    title: Minimal BER Source/Sink Example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ber_sink_0
  id: ber_sink
  parameters: {}
  states: {}
- name: ber_source_0
  id: ber_source
  parameters: {}
  states: {}

connections:
- [ber_source_0, '0', ber_sink_0, '0']

metadata:
  file_format: 1

options:
  parameters:
    generate_options: qt_gui
    id: constellation_mod_demod
    output_language: python
    title: ConstellationMod/Demod With BER
  states: {}

blocks:
- name: qpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ber_sink_1
  id: ber_sink
  parameters: {}
  states: {}
- name: ber_source_1
  id: ber_source
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '32000'
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '11'
    samp_rate: '1'
    sym_rate: 1/sps
    type: fir_filter_ccf
  states: {}

connections:
- [ber_source_1, '0', digital_constellation_modulator_0, '0']
- [blocks_deinterleave_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_deinterleave_0, '1', digital_constellation_decoder_cb_0, '0']
- [blocks_deinterleave_0, '1', qtgui_const_sink_x_0, '1']
- [blocks_pack_k_bits_bb_0, '0', ber_sink_1, '0']
- [blocks_throttle_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_deinterleave_0, '0']

metadata:
  file_format: 1
